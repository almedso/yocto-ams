PR:append =".a2"
# Overwrite issue and issue.net witch almedso/ams banner
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
