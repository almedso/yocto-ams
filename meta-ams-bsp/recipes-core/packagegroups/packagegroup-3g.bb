DESCRIPTION = "Cellular data tools"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS_${PN} = " \
    modemmanager \
"
