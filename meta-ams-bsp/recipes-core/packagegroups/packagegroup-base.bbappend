
RDEPENDS:packagegroup_base += " \
    glibc-utils \
    kbd \
    kbd-keymaps \
    localedef \
"
