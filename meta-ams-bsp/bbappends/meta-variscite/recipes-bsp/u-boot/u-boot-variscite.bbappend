PR:append = ".a2"
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI:append:imx93-var-som-m33 = " file://imx93-var-som-m33/0001-Configure-m33-startup-as-free-rtos.bin.patch "
