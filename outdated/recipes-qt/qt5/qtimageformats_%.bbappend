PACKAGECONFIG_append = " libwebp "
