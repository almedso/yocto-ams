# PACKAGECONFIG += "accessibility eglfs fontconfig gles2 linuxfb tslib gif"

PR_append = ".ams.1"
PACKAGECONFIG += "accessibility eglfs gles2 fontconfig linuxfb "
