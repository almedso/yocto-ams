PACKAGECONFIG:append = " libwebp "
