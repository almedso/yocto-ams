
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

