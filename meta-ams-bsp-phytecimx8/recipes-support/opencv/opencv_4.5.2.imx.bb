# just here to please opencv.4.6.0.imx.bb
# Released under the MIT license (see COPYING.MIT for the terms)
LICENSE = "MIT"

