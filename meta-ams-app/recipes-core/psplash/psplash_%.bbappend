PR:append = ".ams.1"

FILESEXTRAPATHS:prepend:poky := "${THISDIR}/files:"

# see for this recipe + creating a proper format from png / jpg
# https://easylinuxji.blogspot.com/2019/03/replace-default-splash-screen-in-yocto.html

