SUMMMARY = "PLOS Debugging tools"
LICENSE = "MIT"
PR = "r1"

inherit packagegroup

RDEPENDS_${PN} = " \
    i2c-tools \
"

