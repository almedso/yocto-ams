SUMMMARY = "PLOS Profiling tools"
LICENSE = "MIT"
PR = "r1"

inherit packagegroup

RDEPENDS_${PN} = " \
"

