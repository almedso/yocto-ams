RDEPENDS_${PN} += " \
  ${PYTHON_PN}-pytz \
  ${PYTHON_PN}-aniso8601 \
  "
