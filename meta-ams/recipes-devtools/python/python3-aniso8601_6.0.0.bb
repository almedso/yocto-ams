inherit setuptools3
require python-aniso8601.inc

