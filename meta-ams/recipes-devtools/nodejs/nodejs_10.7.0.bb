require nodejs_10.inc

# this comes along with npm version 6.1
# which contains a proces.env.npm_execpath variable (needed for angular cli)
INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=5a3ecac4bf502c40b13b250e05faa09e"

SRC_URI[src.md5sum] = "2b93989c2e08b0404ef8044bf3266f1c"
SRC_URI[src.sha256sum] = "b9691cbc6e6a2e209a9b8cb88fd942802236dae06652080f582304dbdd505ad2"

