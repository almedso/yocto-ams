require nodejs_10.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=be980eb7ccafe287cb438076a65e888c"

SRC_URI[src.md5sum] = "46f47630e088540968962f1ad71b9d0a"
SRC_URI[src.sha256sum] = "d00f1ffdb0a7413eaaf3afc393fb652ea713db135dcd3ccf6809370a07395713"

