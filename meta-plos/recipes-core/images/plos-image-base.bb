SUMMARY = "A console-only image that fully supports the target device \
hardware provided by plos."

LICENSE = "MIT"

IMAGE_FEATURES += " \
"

inherit plos-image
